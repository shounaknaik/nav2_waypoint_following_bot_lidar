Commit message: Change URDF files

File: src/basic_mobile_robot/models/basic_mobile_bot.urdf (robot description, URDF)
Before this commit: robot basic_mobile_bot, 6 links, 5 joints
Links:
- removed link gps_link
- removed link imu_link
Joints:
- removed joint gps_joint
- removed joint imu_joint
